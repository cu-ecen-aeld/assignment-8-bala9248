## base_external/package/aesd-driver/Config.in
```kconfig
config BR2_PACKAGE_AESD_DRIVER
	bool "aesd-driver"
	help
	  loads the driver modules
```
